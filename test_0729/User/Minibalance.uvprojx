# Keil uVision project Minibalance.uvprojx, settings and files
target Minibalance (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Minibalance +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_ HD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\COER;..\FWLIB\inc;..\HARDWARE;..\SYSTEM;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\DMP;..\HARDWARE\IIC;..\HARDWARE\MPU6050;..\HARDWARE\ENCODER;..\HARDWARE\OLED;..\HARDWARE\show;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\ADC;..\HARDWARE\MOTOR;..\HARDWARE\TIMER;..\HARDWARE\EXTI;..\HARDWARE\DataScope_DP;..\HARDWARE\filter;..\HARDWARE\STMFLASH;..\HARDWARE\USARTX;..\HARDWARE\NRF24L01;..\HARDWARE\SPI;..\HARDWARE\CAN;..\HARDWARE\PS2;..\HARDWARE\PWM;..\HARDWARE\controllaw;..\HARDWARE\test_fuction;..\HARDWARE\USER_UI_INPUT;..\HARDWARE\USER_UI_OUTPUT;..\HARDWARE\CONTROL;..\HARDWARE\filter
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c EXIT_interupt.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: system_init.c
  group HARDWARE
    ../HARDWARE/USARTX/: usartx.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/IIC/: IOI2C.c
    ../HARDWARE/LED/: LED.C
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/PWM/: PWM.c
    ../HARDWARE/MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c
    ../HARDWARE/OLED/: test_OLED.c
    ../unuse_lib/KEY/: key.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/filter/: filter.c
    ../HARDWARE/controllaw/: controlLaw.c
    ../HARDWARE/USER_UI_INPUT/: input.c
    ../HARDWARE/USER_UI_OUTPUT/: output.c
    ../HARDWARE/test_fuction/: test_fuction.c
software components: CMSIS:CORE 5.1.2
